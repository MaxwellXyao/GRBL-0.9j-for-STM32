# Keil uVision project Template.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM;..\HARDWARE;..\GRBL_0.9j;..\GRBL_0.9j\cpu_map;..\GRBL_0.9j\defaults
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group GRBL_0.9j
    ../GRBL_0.9j/: eeprom.c nuts_bolts.c coolant_control.c serial.c print.c report.c probe.c spindle_control.c limits.c settings.c system.c stepper.c gcode.c planner.c protocol.c motion_control.c
  group SYSTEM
    ../SYSTEM/: bit.c strprintf.c sys.c delay.c simuspi.c simui2c.c
  group HARDWARE
    ../HARDWARE/: HW_GPIO.c HW_USART.c HW_TIM.c HW_EEPROM.c HW_EXTI.c HW_PWM.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
